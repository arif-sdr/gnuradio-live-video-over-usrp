options:
  parameters:
    category: Custom
    comment: OFDM Video Streaming
    description: Example of an OFDM Transmitter
    generate_options: qt_gui
    id: tx_video_live
    output_language: python
    run_options: run
    title: TX Video
  states: {}

blocks:
- name: bw
  id: variable_qtgui_range
  parameters:
    comment: Bandwidth control
    start: 100e3
    step: 50e3
    stop: 5e6
    value: 900e3
  states: {}
- name: fft_len
  id: variable
  parameters:
    comment: FFT length for OFDM
    value: '64'
  states: {}
- name: gain
  id: variable_qtgui_range
  parameters:
    comment: TX gain control
    start: '20'
    step: '5'
    stop: '200'
    value: '65'
  states: {}
- name: header_formatter
  id: variable
  parameters:
    comment: OFDM header formatter
    value: digital.packet_header_ofdm(occupied_carriers, n_syms=1, len_tag_key=length_tag_key, frame_len_tag_key=length_tag_key, bits_per_header_sym=header_mod.bits_per_symbol(), bits_per_payload_sym=payload_mod.bits_per_symbol(), scramble_header=False)
  states: {}
- name: header_mod
  id: variable
  parameters:
    comment: Header modulation scheme
    value: digital.constellation_bpsk()
  states: {}
- name: length_tag_key
  id: variable
  parameters:
    comment: Packet length tag key
    value: '"packet_len"'
  states: {}
- name: occupied_carriers
  id: variable
  parameters:
    comment: OFDM occupied carriers
    value: (list(range(-26, -21)) + list(range(-20, -7)) + list(range(-6, 0)) + list(range(1, 7)) + list(range(8, 21)) + list(range(22, 27)),)
  states: {}
- name: packet_len
  id: variable
  parameters:
    comment: Video packet length in bytes
    value: '376'
  states: {}
- name: payload_mod
  id: variable
  parameters:
    comment: Payload modulation scheme
    value: digital.constellation_qpsk()
  states: {}
- name: pilot_carriers
  id: variable
  parameters:
    comment: OFDM pilot carriers
    value: ((-21, -7 , 7, 21,),)
  states: {}
- name: pilot_symbols
  id: variable
  parameters:
    comment: OFDM pilot symbols
    value: ((1, 1, 1, -1,),)
  states: {}
- name: rolloff
  id: variable
  parameters:
    comment: |-
      Pulse shaping 
      rolloff factor
    value: '0'
  states: {}
- name: samp_rate
  id: variable_qtgui_range
  parameters:
    comment: Sample rate control
    start: 100e3
    step: 50e3
    stop: 5e6
    value: 600e3
  states: {}
- name: sync_word1
  id: variable
  parameters:
    comment: OFDM sync word 1
    value: '[0., 0., 0., 0., 0., 0., 0., 1.41421356, 0., -1.41421356, 0., 1.41421356, 0., -1.41421356, 0., -1.41421356, 0., -1.41421356, 0., 1.41421356, 0., -1.41421356, 0., 1.41421356, 0., -1.41421356, 0., -1.41421356, 0., -1.41421356, 0., -1.41421356, 0., 1.41421356, 0., -1.41421356, 0., 1.41421356, 0., 1.41421356, 0., 1.41421356, 0., -1.41421356, 0., 1.41421356, 0., 1.41421356, 0., 1.41421356, 0., -1.41421356, 0., 1.41421356, 0., 1.41421356, 0., 1.41421356, 0., 0., 0., 0., 0., 0.]'
  states: {}
- name: sync_word2
  id: variable
  parameters:
    comment: OFDM sync word 2
    value: '[0, 0, 0, 0, 0, 0, -1, -1, -1, -1, 1, 1, -1, -1, -1, 1, -1, 1, 1, 1, 1, 1, -1, -1, -1, -1, -1, 1, -1, -1, 1, -1, 0, 1, -1, 1, 1, 1, -1, 1, 1, 1, -1, 1, 1, 1, 1, -1, 1, -1, -1, -1, 1, -1, 1, -1, -1, -1, -1, 0, 0, 0, 0, 0] '
  states: {}
- name: test_mode
  id: variable_qtgui_chooser
  parameters:
    gui_hint: ' 0,0,1,1'
    label: '[''Video Mode'', ''BER Test Mode'']'
    labels: '[''Video Mode'', ''BER Test Mode'']'
    num_opts: '0'
    options: '[0, 1]'
    type: int
    value: '0'
  states: {}
- name: blocks_interleaved_char_to_complex_0
  id: blocks_interleaved_char_to_complex
  parameters:
    scale_factor: '1.0'
    vector_input: 'False'
  states: {state: disabled}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    comment: Scale signal amplitude
    const: '0.05'
    type: complex
  states: {}
- name: blocks_repack_bits_bb_0
  id: blocks_repack_bits_bb
  parameters:
    comment: Repack bits for QPSK
    endianness: gr.GR_LSB_FIRST
    k: '8'
    l: payload_mod.bits_per_symbol()
    len_tag_key: length_tag_key
  states: {}
- name: blocks_selector_0
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: test_mode
    num_inputs: '2'
    num_outputs: '1'
    output_index: '0'
    type: byte
  states: {}
- name: blocks_stream_to_tagged_stream_0
  id: blocks_stream_to_tagged_stream
  parameters:
    comment: Add packet length tags
    len_tag_key: length_tag_key
    packet_len: packet_len
    type: byte
  states: {}
- name: blocks_tagged_stream_mux_0
  id: blocks_tagged_stream_mux
  parameters:
    comment: Multiplex header and payload
    lengthtagname: length_tag_key
    ninputs: '2'
    type: complex
  states: {}
- name: digital_chunks_to_symbols_xx_0
  id: digital_chunks_to_symbols_xx
  parameters:
    comment: Map header bits to BPSK symbols
    dimension: '1'
    in_type: byte
    out_type: complex
    symbol_table: header_mod.points()
  states: {}
- name: digital_chunks_to_symbols_xx_0_0
  id: digital_chunks_to_symbols_xx
  parameters:
    comment: Map payload bits to QPSK symbols
    dimension: '1'
    in_type: byte
    out_type: complex
    symbol_table: payload_mod.points()
  states: {}
- name: digital_crc32_bb_0
  id: digital_crc32_bb
  parameters:
    check: 'False'
    comment: Add CRC32 for error detection
    lengthtagname: length_tag_key
    packed: 'True'
  states: {}
- name: digital_glfsr_source_x_0
  id: digital_glfsr_source_x
  parameters:
    degree: ' 15'
    mask: ' 0x8001'
    repeat: 'True'
    seed: '1'
    type: byte
  states: {}
- name: digital_ofdm_carrier_allocator_cvc_0
  id: digital_ofdm_carrier_allocator_cvc
  parameters:
    comment: Allocate OFDM carriers
    fft_len: fft_len
    len_tag_key: length_tag_key
    occupied_carriers: occupied_carriers
    output_is_shifted: 'True'
    pilot_carriers: pilot_carriers
    pilot_symbols: pilot_symbols
    sync_words: (sync_word1, sync_word2)
  states: {}
- name: digital_ofdm_cyclic_prefixer_0
  id: digital_ofdm_cyclic_prefixer
  parameters:
    comment: Add cyclic prefix
    cp_len: fft_len//8
    input_size: fft_len
    rolloff: rolloff
    tagname: length_tag_key
  states: {}
- name: digital_packet_headergenerator_bb_0
  id: digital_packet_headergenerator_bb
  parameters:
    comment: Generate OFDM packet headers
    header_formatter: header_formatter.base()
    len_tag_key: length_tag_key
  states: {}
- name: fft_vxx_0
  id: fft_vxx
  parameters:
    comment: IFFT for OFDM
    fft_size: fft_len
    forward: 'False'
    shift: 'True'
    type: complex
    window: ()
  states: {}
- name: network_socket_pdu_1
  id: network_socket_pdu
  parameters:
    comment: Video stream input from network
    host: 127.0.0.1
    mtu: '1500'
    port: '1235'
    type: UDP_SERVER
  states: {}
- name: pdu_pdu_to_stream_x_0
  id: pdu_pdu_to_stream_x
  parameters:
    early_behavior: pdu.EARLY_BURST_APPEND
    type: byte
  states: {}
- name: pdu_pdu_to_stream_x_1
  id: pdu_pdu_to_stream_x
  parameters:
    comment: Convert PDU to stream
    early_behavior: pdu.EARLY_BURST_APPEND
    type: byte
  states: {state: disabled}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    autoscale: 'True'
    bw: samp_rate
    comment: Spectrum display
    fc: '0'
    fftsize: '1024'
    name: FFT Plot
    showports: 'True'
    type: complex
  states: {state: disabled}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    label1: Scope Plot
    label2: ''
    name: Scope Plot
    size: '1024'
    srate: samp_rate
    type: complex
  states: {state: disabled}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    bw0: bw
    center_freq0: 5e9
    comment: |-
      USRP transmitter with 
      LUCB frequency control
    dev_addr: ''
    gain0: gain
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: uhd_usrp_sink_0_0
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    ant1: '"TX/RX"'
    bw0: bw
    bw1: bw
    center_freq0: 5e9
    center_freq1: 5e9
    comment: USRP transmitter
    dev_addr: ''
    gain0: gain
    gain1: gain
    nchan: '2'
    samp_rate: samp_rate
    sync: pc_clock
    time_source0: gpsdo
    type: fc32
  states: {state: disabled}

connections:
- [blocks_multiply_const_vxx_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_multiply_const_vxx_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_multiply_const_vxx_0, '0', uhd_usrp_sink_0, '0']
- [blocks_repack_bits_bb_0, '0', digital_chunks_to_symbols_xx_0_0, '0']
- [blocks_selector_0, '0', blocks_stream_to_tagged_stream_0, '0']
- [blocks_stream_to_tagged_stream_0, '0', digital_crc32_bb_0, '0']
- [blocks_tagged_stream_mux_0, '0', digital_ofdm_carrier_allocator_cvc_0, '0']
- [digital_chunks_to_symbols_xx_0, '0', blocks_tagged_stream_mux_0, '0']
- [digital_chunks_to_symbols_xx_0_0, '0', blocks_tagged_stream_mux_0, '1']
- [digital_crc32_bb_0, '0', blocks_repack_bits_bb_0, '0']
- [digital_crc32_bb_0, '0', digital_packet_headergenerator_bb_0, '0']
- [digital_glfsr_source_x_0, '0', blocks_selector_0, '1']
- [digital_ofdm_carrier_allocator_cvc_0, '0', fft_vxx_0, '0']
- [digital_ofdm_cyclic_prefixer_0, '0', blocks_multiply_const_vxx_0, '0']
- [digital_packet_headergenerator_bb_0, '0', digital_chunks_to_symbols_xx_0, '0']
- [fft_vxx_0, '0', digital_ofdm_cyclic_prefixer_0, '0']
- [network_socket_pdu_1, pdus, pdu_pdu_to_stream_x_0, pdus]
- [network_socket_pdu_1, pdus, pdu_pdu_to_stream_x_1, pdus]
- [pdu_pdu_to_stream_x_0, '0', blocks_selector_0, '0']
- [pdu_pdu_to_stream_x_1, '0', blocks_stream_to_tagged_stream_0, '0']

metadata:
  file_format: 1
